# Keil uVision project QXCGQ.uvprojx, settings and files
target QXCGQ (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: QXCGQ +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include;  .\HARDWARE\FLASH;  .\HARDWARE\IIC;  .\HARDWARE\KEY;  .\HARDWARE\LEDBEEP;  .\HARDWARE\UART;  .\HARDWARE\LED;  .\HARDWARE\DHT11;  .\HARDWARE\DELAY;  .\HARDWARE\PM2.5;  .\HARDWARE\ACTION;  .\HARDWARE\LINKAGE;  .\HARDWARE\LINGHSENSOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c adc.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group HARDWARE
    ./HARDWARE/FLASH/: flash.c
    ./HARDWARE/IIC/: iic.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/UART/: uart.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/DHT11/: dht11.c
    ./HARDWARE/PM2.5/: pm2_5.c
    ./HARDWARE/DELAY/: delay.c
    ./HARDWARE/LINKAGE/: linkage.c
    ./HARDWARE/ACTION/: action.c
    ./HARDWARE/LINGHSENSOR/: lightsensor.c
